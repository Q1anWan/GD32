# IAR project composite_hid_printer.ewp, settings and files
configuration GD32E50X_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_FS
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E50x\Include; ..\..\..\..\..\Firmware\GD32E50x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\class\hid\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\class\hid; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\device\class\printer\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cdc_acm.srec
  ILINK.IlinkOutputFile: project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E50X_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_HS
  ICCARM.CCOptStrategy: 0
  group App
    ../src/: app.c custom_hid_itf.c gd32e50x_hw.c gd32e50x_it.c hid_printer_wrapper.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
  group GD32E50x_Peripherals
    ../../../../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_ctc.c gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32E50x_usbhs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32E50x_usbhs_library/device/class/printer/Source/: printer_core.c
  group USB_Device
    ../../../../../Firmware/GD32E50x_usbhs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Driver
    ../../../../../Firmware/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
