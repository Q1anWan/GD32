# IAR project usbh_msc.ewp, settings and files
configuration GD32E50X_USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32E507xE GD GD32E507xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_FS; USE_FATFS
  ICCARM.CCIncludePath2: ..\inc; ..\fat_fs\inc; ..\..\..\..\..\Firmware\CMSIS; ..\..\..\..\..\Firmware\CMSIS\GD\GD32E50x\Include; ..\..\..\..\..\Firmware\GD32E50x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\driver\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\host\class\msc\Include; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\common; ..\..\..\..\..\Firmware\GD32E50x_usbhs_library\ustd\class\msc; ..\..\..\..\..\Utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio.srec
  ILINK.IlinkOutputFile: USBH_MSC.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32E50X_USBHS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32E50X; GD32E50X_CL; USE_USB_HS; USE_FATFS
  group Application
    ../src/: gd32e50x_it.c gd32e50x_usb_hw.c lcd_font.c lcd_log.c main.c usbh_usr.c
  group CMSIS
    ../src/: system_gd32e50x.c
  group Doc
    ../: readme.txt
  group FATFS
    ../fat_fs/src/: ff.c ffunicode.c
  group GD32E50x_EVAL
    ../../../../../Utilities/: gd32e507z_eval.c
    ../src/: gd32e50x_lcd_eval.c
  group GD32E50x_Peripherals
    ../../../../../Firmware/GD32E50x_standard_peripheral/Source/: gd32e50x_exmc.c gd32e50x_exti.c gd32e50x_gpio.c gd32e50x_misc.c gd32e50x_pmu.c gd32e50x_rcu.c gd32e50x_timer.c gd32e50x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32E50x/Source/IAR/: startup_gd32e50x_cl.s
  group USB_Class
    ../../../../../Firmware/GD32E50x_usbhs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_Driver
    ../../../../../Firmware/GD32E50x_usbhs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32E50x_usbhs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
