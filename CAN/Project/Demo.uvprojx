# Keil uVision project Demo.uvprojx, settings and files
target Demo (6190000::V6.19::ARMCLANG)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\CMSIS;..\FWLIB\Include;..\FWLIB\Source;..\..\Demo\Modules;..\CMSIS\DSP_1.14.2\Include;..\CMSIS\DSP_1.14.2\Include\dsp;..\CMSIS\DSP_1.14.2\PrivateInclude
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: system_gd32f30x.c startup_gd32f30x_hd.s
  group FWLIB
    ../FWLIB/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group DSP
    ../CMSIS/DSP_1.14.2/Include/: arm_math.h
    ../CMSIS/DSP_1.14.2/Source/BasicMathFunctions/: BasicMathFunctions.c BasicMathFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/BayesFunctions/: BayesFunctions.c BayesFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/CommonTables/: CommonTables.c CommonTablesF16.c
    ../CMSIS/DSP_1.14.2/Source/ComplexMathFunctions/: ComplexMathFunctions.c ComplexMathFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/ControllerFunctions/: ControllerFunctions.c
    ../CMSIS/DSP_1.14.2/Source/DistanceFunctions/: DistanceFunctions.c DistanceFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/FastMathFunctions/: FastMathFunctions.c FastMathFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/FilteringFunctions/: FilteringFunctions.c FilteringFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/InterpolationFunctions/: InterpolationFunctions.c InterpolationFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/MatrixFunctions/: MatrixFunctions.c MatrixFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../CMSIS/DSP_1.14.2/Source/StatisticsFunctions/: StatisticsFunctions.c StatisticsFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/SupportFunctions/: SupportFunctions.c SupportFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/SVMFunctions/: SVMFunctions.c SVMFunctionsF16.c
    ../CMSIS/DSP_1.14.2/Source/TransformFunctions/: TransformFunctions.c TransformFunctionsF16.c
  group Modules
    ../Modules/: main.cpp gd32f30x_it.c systick.c Delay.c IIC_Software_GD.cpp SPI_GD.cpp UART_GD.cpp
    ../../Demo/Modules/: Data_Exchange.c QCS_Lite.c
