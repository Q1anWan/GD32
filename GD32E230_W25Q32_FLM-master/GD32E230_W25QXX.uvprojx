# Keil uVision project GD32E230_W25QXX.uvprojx, settings and files
target Cortex-M23 (6190000::V6.19::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E230_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230_W25QXX
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  AfterMake: .\Copy_FLM.bat
  c flags: Optim=7 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\GD32E230_W25Q32_FLM;.\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;.\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;.\Drivers;.\CMSIS;..\GD32E230_W25Q32_FLM-master
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group CMSIS
    ./GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ./GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_spi.c gd32e23x_gpio.c gd32e23x_rcu.c gd32e23x_usart.c
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Drivers
    ./Drivers/: bsp_spi.c bsp_spi.h bsp_uart.h spi_flash.c spi_flash.h bsp_uart.c
  group Config
    ./: custom_config.h
