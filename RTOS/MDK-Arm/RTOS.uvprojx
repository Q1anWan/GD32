# Keil uVision project RTOS.uvprojx, settings and files
target RTOS (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD,__FPU_USED,__FPU_PRESENT
  c include: ..\CMSIS;..\CMSIS\GD\GD32F30x\Include;..\FW\GD32F30x_standard_peripheral\Include;..\FW\GD32F30x_usbd_library\device\Include;..\FW\GD32F30x_usbd_library\usbd\Include;..\USB;..\FW;..\Modules;..\DSP\Include;..\DSP\Include\dsp;..\RT-Thread\bsp;..\RT-Thread\components\finsh;..\RT-Thread\include;..\RT-Thread\include\libc;..\RT-Thread\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8040000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ../CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ../CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group Firmware
    ../FW/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group USBLib
    ../FW/GD32F30x_usbd_library/usbd/Source/: usbd_lld_core.c usbd_lld_int.c
    ../FW/GD32F30x_usbd_library/device/Source/: usbd_core.c usbd_enum.c usbd_pwr.c usbd_transc.c
  group Modules
    ../Modules/: main.cpp
    ../FW/: gd32f30x_it.c
  group DSP
    ../DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../DSP/Source/CommonTables/: CommonTables.c
  group RT-Thread
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../RT-Thread/bsp/: board.c rtconfig.h
    ../RT-Thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
